# IAR project ctrl.ewp, settings and files
configuration Release (8051, debug)
  General.OGChipSelectMenu: CC2530F128 CC2530F128
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
  group (top)
    ../Source/: readme.txt
  group Source
    ../Source/: basic_rf.c clock.c hal_assert.c hal_board.c hal_int.c hal_mcu.c hal_rf.c htu21d.c iic.c info.c main.c uart1.c
