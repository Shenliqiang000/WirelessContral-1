<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <group>
    <name>Source</name>
    <file>
      <name>$PROJ_DIR$\..\Source\basic_rf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\clock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\hal_assert.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\hal_board.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\hal_int.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\hal_mcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\hal_rf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\info.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\main.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\Source\readme.txt</name>
  </file>
</project>


